## Kconfig.projbuild
```kconfig
menu "esp32-mqtt Configuration"

config MQTT_SERVER_URI
    string "mqtt server uri"
    default "mqtt://192.168.1.132"

endmenu
```
